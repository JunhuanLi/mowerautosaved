# Keil uVision project project.uvprojx, settings and files
target Tesla_rtt_429 (ARM-ADS)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Tesla_rtt_429 +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F429_439xx, USE_STDPERIPH_DRIVER
  c include: ..\StmLib\STM32F4xx_StdPeriph_Driver\inc;..\StmLib\CMSIS\Include;..\StmLib\CMSIS;..\include;.;..\Application\include;..\Algorithm\include;..\Communication\include;..\Driver\include;..\OS\include;..\OS\libcpu\arm\cortex-m4;..\..\Tesla_1.0.1.170516_AlphaOS\libcpu\arm\common;..\OS\components\finsh
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep *.o(FSymTab) --keep *.o(VSymTab)
  group STM32_StdPeriph
    ../StmLib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../StmLib/CMSIS/: system_stm32f4xx.c startup_stm32f429_439xx.s
  group other
    ../src/: application.c board.c startup.c stm32f4xx_it.c
  group Application
    ../Application/: delay.c menu.c mower_common.c mower_hw_config.c thread_data_rx.c thread_data_tx.c thread_gps.c thread_imu.c thread_key.c thread_manager.c thread_monitor.c thread_motion.c thread_motor_control.c thread_mpu.c thread_rainbow_led.c thread_slam.c thread_system_control.c thread_ui.c thread_updata.c
  group Algorithm
    ../Algorithm/: ekf7_gps6_mu.c ekf7_odom_mu.c ekf7_tu.c filter.c get_mag_ellipse.c hampel.c magHeading2Geog.c map_ellipse_mapping.c math_custom.c motor_control.c mu_att_ekf.c quat2eulf.c tu_att_ekf.c
  group Communication
    ../Communication/: mower_event.c packet.c queue.c
  group driver
    ../Driver/: 2.4G_spi.c adc.c battery.c beep.c broder_sensor.c bumper_front.c cover_switch.c emergency_switch.c encoder.c encoder_mower.c flash.c hardware.c iic.c iic2.c ist8310.c ist83102.c key.c lcd.c lcd12864_io_spi.c motor.c mow_motor.c mpu6500_spi.c power.c rain_sensor.c rainbow_led.c serial.c sonar.c time_control.c usart.c usart_driver.c wheel_up.c
  group Kernel
    ../OS/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../OS/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../OS/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group finsh
    ../OS/components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
