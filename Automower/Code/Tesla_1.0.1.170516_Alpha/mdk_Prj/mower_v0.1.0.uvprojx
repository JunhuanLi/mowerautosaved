# Keil uVision project mower_v0.1.0.uvprojx, settings and files
target Robot (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mower_stm32f429 +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx
  c include: ..\include;..\src;..\Algorithm;..\Algorithm\include;..\Application;..\Application\include;..\Comunication;..\Comunication\include;..\Driver;..\Driver\include;..\StmLib\STM32F4xx_StdPeriph_Driver\inc;..\StmLib\CMSIS;..\StmLib\CMSIS\Include;..\OS;..\OS\src;..\OS\components\finsh;..\OS\include;..\OS\libcpu\arm\common;..\OS\libcpu\arm\cortex-m4;..\scons_prj;..\OS\components\init;..\OS\components\pthreads;..\OS\components\drivers\include;..\OS\components\drivers\include\drivers;..\OS\components\libc\armlibc;..\OS\components\libc\armlibc\sys
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group StartUp
    ../StmLib/CMSIS/: startup_stm32f429_439xx.s system_stm32f4xx.c
    ../src/: board.c startup.c stm32f4xx_it.c
  group Applicaiton
    ../src/: application.c
    ../Application/: thread_gps.c thread_key.c delay.c thread_ui.c mower_common.c mower_hw_config.c menu.c thread_imu.c thread_monitor.c thread_motion.c thread_updata.c thread_wireless.c debug.c
  group Algorithm
    ../Algorithm/: filter.c math_custom.c motor_control.c ekf7_gps6_mu.c ekf7_odom_mu.c ekf7_tu.c magHeading2Geog.c mu_att_ekf.c quat2eulf.c tu_att_ekf.c hampel.c get_mag_ellipse.c map_ellipse_mapping.c pi.c odom_preprocessing.c send_data.c motion_control.c motion_imu.c motion_mag_line.c motion_math.c motion_sense.c movvarf.c imu_processing.c eul2quatf.c conv_enc.c map_server.c global_planner.c
  group Components
    ../OS/components/pthreads/: clock_time.c mqueue.c pthread.c pthread_attr.c pthread_barrier.c pthread_cond.c pthread_mutex.c pthread_rwlock.c pthread_spin.c pthread_tls.c sched.c semaphore.c
    ../OS/components/drivers/rtc/: alarm.c rtc.c
    ../OS/components/drivers/serial/: serial.c
    ../OS/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group Driver
    ../Driver/: lcd.c usart.c key.c bumper_front.c cover_switch.c emergency_switch.c wheel_up.c rainbow_led.c lcd12864_io_spi.c time_control.c hardware.c 2.4G_spi.c adc.c battery.c beep.c broder_sensor.c encoder.c encoder_mower.c flash.c iic.c iic2.c ist8310.c ist83102.c motor.c mow_motor.c mpu6500_spi.c power.c rain_sensor.c sonar.c usart_driver.c drtc.c stm32f4_rtc.c ICM20602.c
  group StdPeriph
    ../StmLib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Cortex-M4
    ../OS/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../OS/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group OS_Shell
    ../OS/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c shell.c symbol.c msh_file.c
  group OS_Kernel
    ../OS/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c components.c
